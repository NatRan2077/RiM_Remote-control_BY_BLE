# Keil uVision project RiM_040_40_Bootloader.uvprojx, settings and files
target RiM_040_40_Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCOMPILER5062)
  device: CMT4531 HOPERF
  pack: HOPERF.CMT453x_DFP.0.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RiM_040_40_Bootloader
  AfterMake: fromelf --bin --output=.\bin\RiM_040_40_Bootloader.bin .\Objects\RiM_040_40_Bootloader.axf
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CMT453X, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT=1
  c misc: --reduce_paths
  c include: ..\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\cmt453x_std_periph_driver\inc;..\inc\rw;..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_cmt453x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_cmt453x.c
  group FWLB
    ../firmware/cmt453x_std_periph_driver/src/: misc.c cmt453x_gpio.c cmt453x_rcc.c cmt453x_usart.c cmt453x_spi.c cmt453x_qflash.c cmt453x_i2c.c cmt453x_iwdg.c
  group Core
    ../src/: main.c
    ../User/: CRC.c cmt453x_it.c
  group Drivers
    ../User/: USB_Driver.c
  group User
    ../User/: lcd.c memory.c utils.c MD5.c Bootloader.c
