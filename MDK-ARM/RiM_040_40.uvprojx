# Keil uVision project RiM_040_40.uvprojx, settings and files
target RiM_040_40 (5060960::V5.06 update 7 (build 960)::.\ARMCOMPILER5062)
  device: CMT4531 HOPERF
  pack: HOPERF.CMT453x_DFP.0.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RiM_040_40
  AfterMake: fromelf --bin --output=.\bin\RiM_040_40.bin .\Objects\RiM_040_40.axf
  AfterMake: C:\Users\Nikita\Desktop\Ri\PO_for_VV\RiM_Remote-control_BY_BLE\MDK-ARM\PostBuild.exe
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CMT453X, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT=1
  c misc: --reduce_paths
  c include: ..\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\cmt453x_std_periph_driver\inc;..\middlewares\HopeRF\ble_library\hp_ble_profile\dis\diss\api;..\middlewares\HopeRF\ble_library\hp_ble_profile\bas\bass\api;..\middlewares\HopeRF\ble_library\hp_ble_profile\hogp;..\middlewares\HopeRF\ble_library\hp_ble_profile\hogp\hogpd\api;..\middlewares\HopeRF\ble_library\hp_ble_profile\hogp\hogpd\src;..\middlewares\HopeRF\ble_library\hp_ble_profile\custom;..\middlewares\HopeRF\ble_library\hp_ble_profile\custom\custs\api;..\middlewares\HopeRF\ble_library\hp_ble_profile\hrp;..\middlewares\HopeRF\ble_library\hp_ble_profile\hrp\hrps\api;..\middlewares\HopeRF\ble_library\hp_ble_profile\hrp\hrps\src;..\middlewares\HopeRF\ble_library\hp_ble_profile\rdts\rdtsc\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ahi\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\inc;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\src\gap;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\src\gatt;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\hl\src\l2c;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src\llc;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src\lld;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\ble\ll\src\llm;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\em\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\hci\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\ip\sch\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\aes\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\common\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\dbg\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\ecc_p256\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\h4tl\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\ke\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\rwip\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\rfinit\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\arch;..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\common\api;..\middlewares\HopeRF\ble_library\hp_ble_stack\modules\common\src;..\middlewares\HopeRF\ble_library\hp_ble_stack\stack_common;..\inc\rw;..\inc\app_profile;..\middlewares\HopeRF\ble_library\hp_ble_stack\arch;..\middlewares\HopeRF\ble_library\hp_library\adv;..\middlewares\HopeRF\ble_library\hp_library\timer;..\middlewares\HopeRF\ble_library\hp_library\log;..\middlewares\HopeRF\ble_library\hp_library\delay;..\middlewares\HopeRF\ble_library\hp_library\sleep;..\middlewares\HopeRF\ble_library\hp_library\sec;..\middlewares\HopeRF\ble_library\hp_library\ble;..\User\inc;..\User\inc\pt-1.4;..\User\DLMS_COSEM\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1008000 size 0x38000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: ..\middlewares\HopeRF\ble_library\hp_ble_stack\symdef\symbol_g15_central.obj --no_autoat
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_cmt453x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_cmt453x.c
  group FWLB
    ../firmware/cmt453x_std_periph_driver/src/: misc.c cmt453x_adc.c cmt453x_crc.c cmt453x_dma.c cmt453x_exti.c cmt453x_gpio.c cmt453x_rcc.c cmt453x_tim.c cmt453x_usart.c cmt453x_spi.c cmt453x_lpuart.c cmt453x_qflash.c cmt453x_i2c.c cmt453x_iwdg.c
  group BLE_STACK
    ..//middlewares/HopeRF/ble_library/hp_ble_stack/stack_common/: rwip.c
    ../middlewares/HopeRF/ble_library/hp_ble_stack/stack_common/: rwip_driver.c
    ../middlewares/HopeRF/ble_library/hp_ble_stack/host_lib/: cmt453x_host_lib.lib
  group BLE_PROFILE
    ../middlewares/HopeRF/ble_library/hp_ble_profile/: prf.c prf_utils.c prf_utils_128.c
    ../middlewares/HopeRF/ble_library/hp_ble_profile/rdts/rdtsc/src/: rdts_client.c rdts_client_task.c
  group HP_LIB
    ../middlewares/HopeRF/ble_library/hp_library/log/: hp_log_lpuart.c
    ../middlewares/HopeRF/ble_library/hp_library/sleep/: hp_sleep.c
    ../middlewares/HopeRF/ble_library/hp_library/error/: hp_error.c
    ../middlewares/HopeRF/ble_library/hp_library/timer/: hp_timer.c
    ../middlewares/HopeRF/ble_library/hp_library/sec/: hp_sec.c
    ../middlewares/HopeRF/ble_library/hp_library/ble/: hp_ble.c hp_ble_task.c
  group BLE_APP
    ../src/app_profile/: app_rdtsc.c
    ../src/: app_ble.c
  group Core
    ../src/: main.c
    ../User/: messages.c CRC.c log.c cmt453x_it.c calc_fsc.c
  group CONFIG
    ../inc/: app_user_config.h
  group Drivers
    ../User/: USB_Driver.c
  group Threads
    ../User/Threads/: threads_USB.c thread_btn.c threads_BLE.c thread_rim_protocol.c thread_main.c threads_other.c threads_DataRouting.c
    ../User/src/: ble_transport.c service_cmd.c passwords.c
  group User
    ../User/: globals.c lcd.c memory.c utils.c MD5.c dlmsListObj.c
  group DLMS
    ../User/DLMS_COSEM/: cosem.c dlms.c DLMS_COSEM_Handlers_Exchanges.c DLMS_COSEM_Handlers_Methods.c
